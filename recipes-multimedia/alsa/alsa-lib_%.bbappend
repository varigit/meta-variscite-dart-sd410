FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_dart-sd410 = "file://0001-ucm-Add-ucm-files-for-DB410c-board.patch"
